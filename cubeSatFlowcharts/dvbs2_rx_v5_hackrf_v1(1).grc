options:
  parameters:
    author: root
    generate_options: qt_gui
    id: dvbs2_rx_v2
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: Es
  id: variable
  parameters:
    value: '1'
  states: {}
- name: EsN0
  id: variable
  parameters:
    value: 10 ** (esn0_db / 10)
  states: {}
- name: N0
  id: variable
  parameters:
    value: Es / EsN0
  states: {}
- name: VGif
  id: variable_qtgui_range
  parameters:
    label: VGIF
    start: '0'
    step: '0.1'
    stop: '36'
    value: '20'
  states: {}
- name: Vga
  id: variable_qtgui_range
  parameters:
    label: VGA
    start: '0'
    step: '0.1'
    stop: '46'
    value: '24'
  states: {}
- name: c_freq
  id: variable
  parameters:
    value: '4200000000'
  states: {}
- name: code_rate
  id: variable
  parameters:
    value: modcod.upper().replace("8PSK", "").replace("QPSK", "")
  states: {}
- name: constellation
  id: variable
  parameters:
    value: modcod.replace(code_rate, "")
  states: {}
- name: esn0_db
  id: variable_qtgui_range
  parameters:
    label: Es/N0 (dB)
    start: '0'
    step: '0.1'
    stop: '20'
    value: snr
  states: {}
- name: n_rrc_taps
  id: variable
  parameters:
    value: int(2*rrc_delay*sps) + 1
  states: {}
- name: pilot_len
  id: variable
  parameters:
    value: int((360-1)/16)*36
  states: {}
- name: plframe_len
  id: variable
  parameters:
    value: '33282'
  states: {}
- name: plheader_len
  id: variable
  parameters:
    value: '90'
  states: {}
- name: qtgui_freq_offset
  id: variable_qtgui_range
  parameters:
    label: Frequency Offset (Hz)
    start: '-sym_rate/4'
    step: 1e3
    stop: sym_rate/4
    value: freq_offset
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: 6M works but no QPSK
    value: sym_rate * sps
  states: {}
- name: agc_gain
  id: parameter
  parameters:
    label: AGC gain
    type: eng_float
    value: '1'
  states: {}
- name: agc_rate
  id: parameter
  parameters:
    label: AGC update rate
    type: eng_float
    value: '1e-5'
  states: {}
- name: agc_ref
  id: parameter
  parameters:
    label: AGC's reference value
    type: eng_float
    value: '1'
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /tmp/received.ts
    type: byte
    unbuffered: 'True'
  states: {state: disabled}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    comment: '625000'
    samples_per_second: '2000000'
    type: complex
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: '1.0005'
    freq_offset: '0.025'
    noise_voltage: '0.2'
    seed: '0'
    taps: '1.0'
  states: {state: disabled}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    length: '32'
    long_form: 'True'
    type: cc
  states: {state: disabled}
- name: debug
  id: parameter
  parameters:
    comment: '0'
    label: debugging level
    short_id: d
    type: intx
    value: '1'
  states: {}
- name: dvbs2rx_rx_hier_0
  id: dvbs2rx_rx_hier
  parameters:
    agc_gain: agc_gain
    agc_rate: agc_rate
    agc_ref: agc_ref
    debug: debug
    frame_size: frame_size
    gold_code: gold_code
    modcod: modcod
    pl_freq_est_period: pl_freq_est_period
    rolloff: rolloff
    rrc_delay: rrc_delay
    rrc_nfilts: rrc_nfilts
    sps: sps
    sym_rate: sym_rate
    sym_sync_damping: sym_sync_damping
    sym_sync_loop_bw: sym_sync_loop_bw
  states: {}
- name: frame_size
  id: parameter
  parameters:
    label: FECFRAME size
    short_id: f
    type: str
    value: normal
  states: {}
- name: freq_offset
  id: parameter
  parameters:
    comment: '1000'
    label: simulated carrier frequency offset in Hz
    type: eng_float
    value: '0'
  states: {}
- name: gold_code
  id: parameter
  parameters:
    label: Gold code
    type: intx
    value: '0'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from math import pi, sqrt
  states: {}
- name: in_file
  id: parameter
  parameters:
    label: path to input file containing an MPEG TS stream
    type: str
    value: ../data/example.ts
  states: {}
- name: interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    comment: firdes.root_raised_cosine(sps, samp_rate, sym_rate, rolloff, n_rrc_taps)
    interp: int(sps / 2)
    taps: firdes.root_raised_cosine(sps, samp_rate, sym_rate, rolloff, 128)
    type: ccf
  states: {state: disabled}
- name: modcod
  id: parameter
  parameters:
    label: MODCOD
    short_id: m
    type: str
    value: QPSK3/5
  states: {}
- name: network_udp_sink_0
  id: network_udp_sink
  parameters:
    addr: 127.0.0.1
    header: '0'
    payloadsize: '1472'
    port: '12348'
    send_eof: 'False'
    type: byte
  states: {}
- name: network_udp_source_0
  id: network_udp_source
  parameters:
    comment: '1316'
    header: '0'
    ipv6: 'False'
    notify_missed: 'False'
    port: '12346'
    src_zeros: 'False'
    type: complex
  states: {}
- name: pl_freq_est_period
  id: parameter
  parameters:
    label: PL synchronizer's frequency estimation period in frames
    type: intx
    value: '20'
  states: {}
- name: qtgui_const_sink_x_1
  id: qtgui_const_sink_x
  parameters:
    gui_hint: tabs@4
    legend: 'False'
    name: '"PL Sync Output out"'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_1_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: tabs@2
    legend: 'False'
    name: '"Symbol Sync Output out"'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_1_0_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: tabs@2
    legend: 'False'
    name: '"Symbol Sync Output in"'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_1_1
  id: qtgui_const_sink_x
  parameters:
    gui_hint: tabs@4
    legend: 'False'
    name: '"PL Sync Output in"'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: samp_rate
    fc: c_freq
    fftsize: '1024'
    grid: 'True'
    gui_hint: tabs@1
    label1: Before
    label2: After
    name: '"Frequency Correction"'
    nconnections: '2'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: samp_rate
    fc: c_freq
    fftsize: '1024'
    grid: 'True'
    gui_hint: tabs@1
    label1: Before
    label2: After
    name: '"Frequency Correction"'
    nconnections: '2'
    type: complex
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    gui_hint: tabs@3
    label1: I
    label2: Q
    size: plframe_len - pilot_len - plheader_len
    srate: sym_rate
    type: complex
    ylabel: PLFRAME Symbols
  states: {}
- name: qtgui_time_sink_x_1_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    gui_hint: tabs@3
    label1: I
    label2: Q
    size: plframe_len - pilot_len - plheader_len
    srate: sym_rate
    type: complex
    ylabel: PLFRAME Symbols
  states: {}
- name: rolloff
  id: parameter
  parameters:
    label: rolloff factor
    short_id: r
    type: eng_float
    value: '0.2'
  states: {}
- name: rrc_delay
  id: parameter
  parameters:
    label: RRC filter delay in symbol periods
    type: intx
    value: '25'
  states: {}
- name: rrc_nfilts
  id: parameter
  parameters:
    label: number of branches on the polyphase RRC filter
    type: intx
    value: '128'
  states: {}
- name: snr
  id: parameter
  parameters:
    label: starting SNR in dB
    type: eng_float
    value: '10'
  states: {}
- name: soapy_hackrf_source_0
  id: soapy_hackrf_source
  parameters:
    bandwidth: samp_rate
    center_freq: c_freq
    gain: Vga
    samp_rate: samp_rate
    type: fc32
    vga: VGif
  states: {state: disabled}
- name: sps
  id: parameter
  parameters:
    label: oversampling ratio in samples per symbol
    short_id: o
    type: eng_float
    value: '2'
  states: {}
- name: sym_rate
  id: parameter
  parameters:
    comment: '1000000'
    label: symbol rate in bauds
    short_id: s
    type: intx
    value: '1000000'
  states: {}
- name: sym_sync_damping
  id: parameter
  parameters:
    label: symbol synchronizer's damping factor
    type: eng_float
    value: '1.0'
  states: {}
- name: sym_sync_loop_bw
  id: parameter
  parameters:
    label: symbol synchronizer's loop bandwidth
    type: eng_float
    value: '0.0045'
  states: {}
- name: tabs
  id: qtgui_tab_widget
  parameters:
    gui_hint: 0,0
    label0: Simulation
    label1: Frequency Correction
    label2: Symbol Sync
    label3: Frame Recovery
    label4: Phase Recovery
    num_tabs: '5'
  states: {}

connections:
- [blocks_null_source_0, '0', qtgui_freq_sink_x_0_0, '1']
- [blocks_throttle2_0, '0', channels_channel_model_0, '0']
- [blocks_throttle2_0, '0', dvbs2rx_rx_hier_0, '0']
- [blocks_throttle2_0, '0', interp_fir_filter_xxx_0, '0']
- [blocks_throttle2_0, '0', qtgui_const_sink_x_1_0_0, '0']
- [blocks_throttle2_0, '0', qtgui_const_sink_x_1_1, '0']
- [blocks_throttle2_0, '0', qtgui_freq_sink_x_0_0, '0']
- [blocks_throttle2_0, '0', qtgui_time_sink_x_1_0, '0']
- [channels_channel_model_0, '0', dvbs2rx_rx_hier_0, '0']
- [dc_blocker_xx_0, '0', dvbs2rx_rx_hier_0, '0']
- [dvbs2rx_rx_hier_0, '0', blocks_file_sink_0_0, '0']
- [dvbs2rx_rx_hier_0, '0', network_udp_sink_0, '0']
- [dvbs2rx_rx_hier_0, '1', qtgui_const_sink_x_1_0, '0']
- [dvbs2rx_rx_hier_0, '2', qtgui_const_sink_x_1, '0']
- [dvbs2rx_rx_hier_0, '2', qtgui_time_sink_x_1, '0']
- [dvbs2rx_rx_hier_0, '3', qtgui_freq_sink_x_0, '1']
- [dvbs2rx_rx_hier_0, '4', qtgui_freq_sink_x_0, '0']
- [interp_fir_filter_xxx_0, '0', dvbs2rx_rx_hier_0, '0']
- [interp_fir_filter_xxx_0, '0', qtgui_const_sink_x_1_0_0, '0']
- [interp_fir_filter_xxx_0, '0', qtgui_const_sink_x_1_1, '0']
- [interp_fir_filter_xxx_0, '0', qtgui_freq_sink_x_0_0, '0']
- [interp_fir_filter_xxx_0, '0', qtgui_time_sink_x_1_0, '0']
- [network_udp_source_0, '0', blocks_throttle2_0, '0']
- [network_udp_source_0, '0', channels_channel_model_0, '0']
- [soapy_hackrf_source_0, '0', blocks_throttle2_0, '0']
- [soapy_hackrf_source_0, '0', dvbs2rx_rx_hier_0, '0']
- [soapy_hackrf_source_0, '0', interp_fir_filter_xxx_0, '0']
- [soapy_hackrf_source_0, '0', qtgui_const_sink_x_1_0_0, '0']
- [soapy_hackrf_source_0, '0', qtgui_const_sink_x_1_1, '0']
- [soapy_hackrf_source_0, '0', qtgui_freq_sink_x_0_0, '0']
- [soapy_hackrf_source_0, '0', qtgui_time_sink_x_1_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
